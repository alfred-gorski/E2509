# Keil uVision project Example.uvproj, settings and files
target Example_Release (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Example_Release
  c flags: Optim=4 oTime=1
  c define: RELEASE
  c include: .\Inc;.\Inc\RB;.\Inc\HW;.\Cfg
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Cfg/: STM32F10xxx_Startup.s STM32F10xxx_Config.c
  group Sources
    ./: Example.c
    ./Src/: Fifo.c U_LEDMatrix.c U_Queue.c
  group Controller
    ./Src/: Reset.c
    ./Src/HW/: HW_TIM.c HW_RCC.c HW_STK.c HW_FLASH.c HW_NVIC.c HW_GPIO.c HW_SPI.c HW_USART.c
  group Retarget
    ./Src/: Retarget.c
  group Debug
    ./Src/: Debug.c
  group Drivers
    ./Src/: DrvUSART.c U_DrvSPI.c U_GPIOConfig.c U_DrvTimer.c
target Example_Debug_STLink2 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Example_Debug
  c flags: Optim=1
  c define: DEBUG
  c include: .\Inc;.\Inc\RB;.\Inc\HW;.\Cfg
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Example_Debug_UL2 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Example_Debug +hex
  c flags: Optim=1
  c define: DEBUG
  c include: .\Inc;.\Inc\RB;.\Inc\HW;.\Cfg
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Example_Debug_Simul (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: as above
  output: Example_Debug
  c flags: Optim=1
  c define: DEBUG FIFO_ARRAY_LOG2LEN=6
  c include: .\Inc;.\Inc\RB;.\Inc\HW;.\Cfg
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
